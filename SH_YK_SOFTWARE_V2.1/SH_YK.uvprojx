# Keil uVision project SH_YK.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SH_YK +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output  ./OBJ/SH_YK.bin ./OBJ/SH_YK.axf
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\APP;.\BSP;.\BSP\ADC;.\BSP\DELAY;.\BSP\MALLOC;.\STM32F10x_FWLib\inc;.\STM32F10x_FWLib\src;.\SYSTEM\CORE;.\SYSTEM\SYS;.\SYSTEM\USER;.\SYSTEM;.\STM32F10x_FWLib;.\BSP\OLED;.\BSP\LED;.\BSP\BUTTON;.\BSP\USART;.\BSP\MultiTimer;.\BSP\MultiButton;.\BSP\TIMER;.\BSP\UGUI;.\BSP\RTC;.\BSP\IWDG;.\BSP\STMFLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./APP/: main.c
  group BSP
    ./BSP/ADC/: adc.c
    ./BSP/DELAY/: delay.c
    ./BSP/MALLOC/: malloc.c
    ./BSP/OLED/: OLED.c
    ./BSP/USART/: usart.c
    ./BSP/BUTTON/: BUTTON.c
    ./BSP/LED/: LED.c
    ./BSP/MultiButton/: multi_button.c
    ./BSP/MultiTimer/: multi_timer.c
    ./BSP/UGUI/: ugui.c
    ./BSP/TIMER/: TIMER.C
    ./BSP/RTC/: rtc.c
    ./BSP/IWDG/: iwdg.c
    ./BSP/STMFLASH/: stmflash.c
  group SYSTEM
    ./SYSTEM/CORE/: core_cm3.c startup_stm32f10x_md.s
    ./SYSTEM/SYS/: sys.c
    ./SYSTEM/USER/: system_stm32f10x.c stm32f10x_it.c
  group FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
